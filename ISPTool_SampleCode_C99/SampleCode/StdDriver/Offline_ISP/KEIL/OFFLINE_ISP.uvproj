# Keil uVision project OFFLINE_ISP.uvproj, settings and files
target Offline_ISP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: Offline_ISP
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\Library\StdDriver\inc;..\;..\ff8\src;..\HAL_Driver;..\ISP_HID_20;..\..\..\..\Library\UsbHostLib\inc;..\ISP_OFFLINE;..\STORAGE;..\LUA
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: main.c Voltage.lib isp.c
    ../ISP_OFFLINE/: ISP_CMD.c ISPLib.c
  group Library
    ../../../../Library/StdDriver/src/: timer.c retarget.c fmc.c
  group USB_OFFLINE
    ../ISP_OFFLINE/: isplib_uart.c
