# Keil uVision project OFFLINE_ISP.uvproj, settings and files
target HSUSBD_Mass_Storage_Offline_ISP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: HSUSBD_Mass_Storage_Offline_ISP
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M480\Include;..\..\..\..\Library\StdDriver\inc;..\;..\ff8\src;..\HAL_Driver;..\ISP_HID_20;..\..\..\..\Library\UsbHostLib\inc;..\ISP_OFFLINE;..\STORAGE;..\LUA
  asm define: Stack_Size=0xb000 Heap_Size=0xb000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: main.c Voltage.lib lua_isp.c
    ../ISP_OFFLINE/: ISP_CMD.c ISPLib.c
    ../../../../Library/UsbHostLib/src_hid/: hid_core.c
  group Library
    ../../../../Library/StdDriver/src/: hsusbd.c spim.c timer.c retarget.c
  group USBD_MSC
    ../: MassStorage.c descriptors.c
    ../../../../Library/UsbHostLib/src_core/: mem_alloc.c usb_core.c ohci.c hub.c
  group STORAGE
    ../STORAGE/: SPIM_SPI_FLASH.c USB_HOST_CALL.C
  group FATFS
    ../ff8/src/: ff.c diskio.c
    ../ff8/src/option/: ccsbcs.c
  group LUA
    ../LUA/: lapi.c lauxlib.c lbaselib.c lbitlib.c lcode.c lcorolib.c lctype.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lundump.c lutf8lib.c lvm.c lzio.c
  group USB_OFFLINE
    ../ISP_OFFLINE/: ISP_FILE_ACCESS.c isplib_uart.c
